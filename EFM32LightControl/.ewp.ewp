# IAR project .ewp.ewp, settings and files
configuration Default (ARM, debug)
  General.OGChipSelectEditMenu: EFM32GG990F1024 SiliconLaboratories EFM32GG990F1024
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: EFM32GG990F1024=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$; ..\..\..\..\..\..\SiliconLabs\SimplicityStudio\v5\developer\sdks\gecko_sdk_suite\v3.0\platform\common\toolchain\inc; ..\..\..\..\..\..\SiliconLabs\SimplicityStudio\v5\developer\sdks\gecko_sdk_suite\v3.0\platform\emlib\inc; ..\..\..\..\..\..\SiliconLabs\SimplicityStudio\v5\developer\sdks\gecko_sdk_suite\v3.0\platform\CMSIS\Include; ..\..\..\..\..\..\SiliconLabs\SimplicityStudio\v5\developer\sdks\gecko_sdk_suite\v3.0\platform\Device\SiliconLabs\EFM32GG\Include; config; autogen
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: EFM32GG990F1024=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: .ewp.s37
  ILINK.IlinkOutputFile: .ewp.out
  ILINK.IlinkIcfFile: autogen/linkerfile.icf
  group (top)
    ./: .ewp.ipcf
